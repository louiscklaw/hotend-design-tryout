File: hardware/bottom_board/bottom_board.kicad_sch (KiCad schematic)
At the start: 11 parts

Commit message: update,
Parts:
- gave numbers to parts that had none: 11
